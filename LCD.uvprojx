# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Step_Light_Led +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Driver\CMSIS\Driver\Source;..\Driver\CMSIS\Driver\Include;..\Driver\CMSIS\Include;..\Driver\STM32F1xx_HAL_Driver\Src;..\Driver\STM32F1xx_HAL_Driver\Inc;..\Driver\SYSTEM\delay;..\Driver\SYSTEM\sys;..\Driver\SYSTEM\usart;..\USER;..\Driver\BSP\LED;..\Driver\BSP\exit;..\Driver\BSP\KEY;..\Driver\BSP\IWDG;..\Driver\BSP\WWDG;..\Driver\BSP\BTime;..\Driver\BSP\Gtime_PWM;..\Driver\BSP\ICGTIME;..\Driver\BSP\PulseCount;..\Driver\BSP\ALL;..\Driver\BSP\OLED
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../Driver/CMSIS/Driver/Source/: system_stm32f1xx.c
    ../USER/: stm32f1xx_it.c stm32f1xx_it.h main.c
  group BSP
    ../Driver/BSP/LED/: led.c led.h
    ../Driver/BSP/KEY/: key.c
    ../Driver/BSP/exit/: exit.c exit.h
    ../Driver/BSP/IWDG/: iwdg.c iwdg.h
    ../Driver/BSP/WWDG/: wwdg.c wwdg.h
    ../Driver/BSP/ALL/: hoctime.c hoctime.h htimedead.c htimedead.h lcd.c lcd.h
  group SYSTEM
    ../Driver/SYSTEM/delay/: delay.c delay.h
    ../Driver/SYSTEM/sys/: sys.c sys.h
    ../Driver/SYSTEM/usart/: usart.c usart.h
  group Startup
    ../Driver/CMSIS/Driver/Source/: startup_stm32f103xe.s
  group Driver_HAL
    ../Driver/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
    ../Driver/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h mpu_armv7.h
